<?xml version='1.0' encoding='utf-8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>spectral</value></param>
<param><key>title</key><value>Analizador con Audio</value></param>
<param><key>author</key><value>Daniel Diaz</value></param>
<param><key>description</key><value>Analizador con Audio</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>audio_decim</value></param>
<param><key>value</key><value>10</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>num_channels</value></param>
<param><key>value</key><value>16</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>tun_freq</value></param>
<param><key>value</key><value>initial_freq + (tun_freq_channel)*pow(2,1+bandwidth)</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>pow(2,2+bandwidth)*1e6</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>filter_decim</value></param>
<param><key>value</key><value>int(pow(2,2+bandwidth)*1e6/400e3)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>tun_gain</value></param>
<param><key>label</key><value>UHD Gain</value></param>
<param><key>value</key><value>10</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>20</value></param>
<param><key>step</key><value>1</value></param>
<param><key>widget</key><value>knob</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>7,2,1,1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>initial_freq_2</value></param>
<param><key>label</key><value>Freq (MHz)</value></param>
<param><key>value</key><value>104.3</value></param>
<param><key>start</key><value>1</value></param>
<param><key>stop</key><value>250</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>widget</key><value>slider</value></param>
<param><key>orient</key><value>Qt.Vertical</value></param>
<param><key>gui_hint</key><value>0,9,10,1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>final_freq</value></param>
<param><key>value</key><value>110</value></param>
<param><key>type</key><value>eng_float</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>gain</value></param>
<param><key>label</key><value>Default Gain</value></param>
<param><key>value</key><value>0</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>short_id</key><value>g</value></param>
</block>
<block>
<key>variable_qtgui_label</key>
<param><key>id</key><value>variable_qtgui_label_0</value></param>
<param><key>label</key><value>Centra Freq (MHz)</value></param>
<param><key>type</key><value>real</value></param>
<param><key>value</key><value>tun_freq</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>volume</value></param>
<param><key>label</key><value>Volume</value></param>
<param><key>value</key><value>1</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>10</value></param>
<param><key>step</key><value>0.1</value></param>
<param><key>widget</key><value>knob</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>gui_hint</key><value>7,3,1,1</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>audio_output</value></param>
<param><key>label</key><value>Audio Output Device</value></param>
<param><key>value</key><value></value></param>
<param><key>type</key><value>string</value></param>
<param><key>short_id</key><value>O</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>(tun_freq)*1e6</value></param>
<param><key>bw</key><value>pow(2,1+bandwidth)*1e6</value></param>
<param><key>gui_hint</key><value>4,0,2,8</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>bandwidth</value></param>
<param><key>label</key><value>Channel BandWidth</value></param>
<param><key>type</key><value>int</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>value</key><value>0</value></param>
<param><key>options</key><value>range(4)</value></param>
<param><key>labels</key><value>['2','4','8','16']</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
</block>
<block>
<key>variable_qtgui_chooser</key>
<param><key>id</key><value>tun_freq_channel</value></param>
<param><key>label</key><value>Channel</value></param>
<param><key>type</key><value>int</value></param>
<param><key>num_opts</key><value>0</value></param>
<param><key>value</key><value>0</value></param>
<param><key>options</key><value>range(num_channels)</value></param>
<param><key>labels</key><value>[]</value></param>
<param><key>widget</key><value>radio_buttons</value></param>
<param><key>orient</key><value>Qt.QHBoxLayout</value></param>
<param><key>gui_hint</key><value>0,2,1,6</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>initial_freq</value></param>
<param><key>label</key><value>Initial Freq (MHz)</value></param>
<param><key>type</key><value>real</value></param>
<param><key>value</key><value>initial_freq_2</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>FFT Plot</value></param>
<param><key>fftsize</key><value>512</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>fc</key><value>(tun_freq)*1e6</value></param>
<param><key>bw</key><value>pow(2,1+bandwidth)*1e6</value></param>
<param><key>gui_hint</key><value>2,0,2,8</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>dev_addr</key><value></value></param>
<param><key>sync</key><value></value></param>
<param><key>clock_rate</key><value>0.0</value></param>
<param><key>sd_spec0</key><value>A:AB</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>center_freq0</key><value>(tun_freq)*1e6+bandwidth-bandwidth</value></param>
<param><key>gain0</key><value>tun_gain</value></param>
<param><key>ant0</key><value></value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>name</key><value>QT GUI Plot</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
</block>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>
